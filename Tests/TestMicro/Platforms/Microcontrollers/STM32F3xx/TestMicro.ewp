# IAR project TestMicro.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303xC ST STM32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F303xC; _STM32F303xE; MICROCONTROLLER; XDEBUG; DIO_ACTIVE; DIOUART_ACTIVE; DIOUSB_ACTIVE; DIOI2C_ACTIVE; DIOSPI_ACTIVE; DIOGPIO_ACTIVE
  ICCARM.CCIncludePath2: ..\..\..\Application; ..\..\..\..\..\GENFrameWork\GEN\Utils; ..\..\..\..\..\GENFrameWork\GEN\Main; ..\..\..\..\..\GENFrameWork\GEN\DataIO; ..\..\..\..\..\GENFrameWork\GEN\DataIO\I2C; ..\..\..\..\..\GENFrameWork\GEN\DataIO\SPI; ..\..\..\..\..\GENFrameWork\GEN\Platforms\Microcontrollers\STM32Fxxx; ..\..\..\..\..\GENFrameWork\GEN\Platforms\Microcontrollers\STM32Fxxx\STM32F3xxLibrary\Inc; ..\..\..\..\..\GENFrameWork\GEN\Platforms\Microcontrollers\STM32Fxxx\STM32F3xxLibrary\Drivers\STM32F3xx_HAL_Driver\Inc; ..\..\..\..\..\GENFrameWork\GEN\Platforms\Microcontrollers\STM32Fxxx\STM32F3xxLibrary\Drivers\CMSIS\Include; ..\..\..\..\..\GENFrameWork\GEN\Platforms\Microcontrollers\STM32Fxxx\STM32F3xxLibrary\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ..\..\..\..\..\GENFrameWork\GEN\Platforms\Microcontrollers\STM32Fxxx\STM32F3xxLibrary\Drivers\CMSIS\Device\ST\STM32F3xx\Include; ..\..\..\..\..\GENFrameWork\GEN\Platforms\Microcontrollers\STM32Fxxx\STM32F3xxLibrary\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\GENFrameWork\GEN\Platforms\Microcontrollers\STM32Fxxx\STM32F3xxLibrary\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: TestMicro.srec
  ILINK.IlinkOutputFile: TestMicro.out
  ILINK.IlinkIcfFile: TestMicro.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../../../Application/: TestMicro.cpp TestMicro.h
  group GEN/DataIO
    ../../../../GEN/DataIO/: DIODevice.h DIODeviceI2C.h DIOFactory.cpp DIOFactory.h DIOGPIO.h DIOStream.cpp DIOStream.h DIOStreamConfig.cpp DIOStreamConfig.h DIOStreamDevice.cpp DIOStreamDevice.h DIOStreamI2C.cpp DIOStreamI2C.h DIOStreamI2CConfig.cpp DIOStreamI2CConfig.h DIOStreamSPI.cpp DIOStreamSPI.h DIOStreamSPIConfig.cpp DIOStreamSPIConfig.h DIOStreamUART.cpp DIOStreamUART.h DIOStreamUARTConfig.cpp DIOStreamUARTConfig.h DIOStreamUSB.cpp DIOStreamUSB.h DIOStreamUSBConfig.cpp DIOStreamUSBConfig.h DIOStreamUSBLocalEnumDevices.cpp DIOStreamUSBLocalEnumDevices.h DIOURL.cpp DIOURL.h
  group GEN/DataIO/I2C
    ../../../../GEN/DataIO/I2C/: DIOI2C6AxisTrackingLSM303DLHC.cpp DIOI2C6AxisTrackingLSM303DLHC.h DIOI2CLightSensorTSL2561.cpp DIOI2CLightSensorTSL2561.h
  group GEN/DataIO/SPI
    ../../../../GEN/DataIO/SPI/: DIOSPILCDScreenPCF8833.cpp DIOSPILCDScreenPCF8833.h
  group GEN/Main
    ../../../../GEN/Main/: Main.cpp Main.h
  group GEN/Platforms/STM32Fxxx
    ../../../../GEN/Platforms/Microcontrollers/STM32Fxxx/: DIOSTM32FxxxFactory.cpp DIOSTM32FxxxFactory.h DIOSTM32FxxxGPIO.cpp DIOSTM32FxxxGPIO.h DIOSTM32FxxxStreamI2C.cpp DIOSTM32FxxxStreamI2C.h DIOSTM32FxxxStreamSPI.cpp DIOSTM32FxxxStreamSPI.h DIOSTM32FxxxStreamUART.cpp DIOSTM32FxxxStreamUART.h DIOSTM32FxxxStreamUSB.cpp DIOSTM32FxxxStreamUSB.h STM32FxxxMain.cpp STM32FxxxMain.h XSTM32Fxxx_HAL.h XSTM32FxxxDateTime.cpp XSTM32FxxxDateTime.h XSTM32FxxxDebug.cpp XSTM32FxxxDebug.h XSTM32FxxxFactory.cpp XSTM32FxxxFactory.h XSTM32FxxxRand.cpp XSTM32FxxxRand.h XSTM32FxxxSleep.cpp XSTM32FxxxSleep.h XSTM32FxxxSystem.cpp XSTM32FxxxSystem.h XSTM32FxxxThread.cpp XSTM32FxxxThread.h XSTM32FxxxTimer.cpp XSTM32FxxxTimer.h
  group GEN/Platforms/STM32Fxxx/STM32F3xxLibrary
    ../../../../GEN/Platforms/Microcontrollers/STM32Fxxx/STM32F3xxLibrary/Src/: gen_usbd_desc.c stm32f3xx_hal_msp.c stm32f3xx_it.c STM32FxxxIni.cpp usb_device.c usbd_cdc_if.c usbd_conf.c
    ../../../../GEN/Platforms/Microcontrollers/STM32Fxxx/STM32F3xxLibrary/Inc/: STM32FxxxIni.h
  group GEN/Platforms/STM32Fxxx/STM32F3xxLibrary/CMSIS
    ../../../../GEN/Platforms/Microcontrollers/STM32Fxxx/STM32F3xxLibrary/Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/iar/: startup_stm32f303xc.s
    ../../../../GEN/Platforms/Microcontrollers/STM32Fxxx/STM32F3xxLibrary/Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
  group GEN/Platforms/STM32Fxxx/STM32F3xxLibrary/Middlewares/USB_Device_Library
    ../../../../GEN/Platforms/Microcontrollers/STM32Fxxx/STM32F3xxLibrary/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../../../GEN/Platforms/Microcontrollers/STM32Fxxx/STM32F3xxLibrary/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group GEN/Platforms/STM32Fxxx/STM32F3xxLibrary/STM32F3xx_HAL_Driver
    ../../../../GEN/Platforms/Microcontrollers/STM32Fxxx/STM32F3xxLibrary/Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
  group GEN/Utils
    ../../../../GEN/Utils/: XApplication.cpp XApplication.h XBase.cpp XBase.h XBuffer.cpp XBuffer.h XDebug.cpp XDebug.h XFactory.cpp XFactory.h XFSMachine.cpp XFSMachine.h XPublisher.cpp XPublisher.h XSleep.cpp XSleep.h XString.cpp XString.h XSystem.cpp XSystem.h XThread.cpp XThread.h XThreadListNonPreemptive.cpp XThreadListNonPreemptive.h XTimer.cpp XTimer.h XVariant.cpp XVariant.h XVector.h
